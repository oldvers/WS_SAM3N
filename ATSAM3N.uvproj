# Keil uVision project ATSAM3N.uvproj, settings and files
target SAM3N4C (ARM-ADS)
  device: SAM3N4C Atmel
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x400000-0x43FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ATSAM3N +hex
  AfterMake: fromelf --bin --output=.\exe\ATSAM3N.bin .\obj\ATSAM3N.axf
  AfterMake: fromelf -c --output=.\lst\Full_Listing.txt .\obj\ATSAM3N.axf
  c flags: Optim=1 OneElfS=1
  c define: sam3n4
  c misc: --c99
  c include: .\src;.\src\CMSIS\;.\src\FreeRTOS\;.\src\FreeRTOS\Source\include\;.\src\FreeRTOS\Source\portable\RVDS\ARM_CM3\;.\src\SAM3NLibChip\;.\src\SAM3NLibChip\include\;.\src\SAM3NLibBoard\;.\src\SAM3NLibBoard\include\;.\src\TivaWare\GrLib
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group CMSIS
    ./src/CMSIS/: system_SAM3N.c core_cm3.c startup_SAM3N.s
  group Debug
    ./src/Debug/: retarget.c HardFault.s
  group FreeRTOS
    ./src/FreeRTOS/: FreeRTOSConfig.h
    ./src/FreeRTOS/Source/: timers.c croutine.c event_groups.c list.c queue.c tasks.c
    ./src/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ./src/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group LibChip
    ./src/SAM3NLibChip/source/: wdt.c pio.c pmc.c spi.c twi.c twid.c usart.c
  group LibBoard
    ./src/SAM3NLibBoard/source/: led.c ili9225.c lcd.c board_lowlevel.c spim_driver.c
  group GrLib
    ./src/TivaWare/GrLib/: canvas.c charmap.c checkbox.c circle.c container.c context.c image.c imgbutton.c keyboard.c line.c listbox.c offscr1bpp.c offscr4bpp.c offscr8bpp.c pushbutton.c radiobutton.c rectangle.c slider.c string.c widget.c
    ./src/TivaWare/GrLib/fonts/: fontbookmanold20b.c fontfixed6x8.c
  group Main
    ./src/: main.c tasklcd.c tasktwi.c
